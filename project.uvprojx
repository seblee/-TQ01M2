# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx +hex
  AfterMake: fromelf --bin !L --output @H.bin
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,RT_USING_ARM_LIBC,__FPU_PRESENT=1,__FPU_USED
  c include: .;..\..\include;applications;.;drivers;Libraries\STM32F4xx_StdPeriph_Driver\inc;Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\STM32_Cryptographic_Library\inc;Libraries\CMSIS\Include;packages\at_device-latest;packages\cJSON-v1.0.2;.\packages\fal-latest\inc;packages\pahomqtt-latest\MQTTPacket\src;packages\pahomqtt-latest\MQTTClient-RT;.\packages\mbedtls-v2.6.0\mbedtls\include;.\packages\mbedtls-v2.6.0\mbedtls\include\mbedtls;.\packages\mbedtls-v2.6.0\ports\inc;.\packages\webclient-v2.0.1\inc;.\packages\pcf8563;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\filesystems\elmfat;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\pthreads;..\..\components\libc\time;..\..\components\net\at\include;..\..\components\net\at\at_socket;..\..\components\net\sal_socket\include;..\..\components\net\sal_socket\include\socket;..\..\components\net\sal_socket\impl;..\..\components\net\sal_socket\include\dfs_net;..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\components\net\sal_socket\include\socket\sys_socket;.\kits;.\usr\modules;.\TQ01_net;.\FreeModbus\modbus\include;.\FreeModbus\port;.\FreeModbus\modbus\rtu;.\FreeModbus\port\modbus_monitor_slave
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x90000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
    ./applications/: global_var.c
  group Drivers
    drivers/: board.c stm32f4xx_it.c usart.c gpio.c
    ./drivers/: adc_bsp.c cpad_bsp.c dio_bsp.c i2c_bsp.c led_bsp.c Moter.c pwm_bsp.c rtc_bsp.c TH_Sensor_Bsp.c watchdog_bsp.c drv_swj.c
    ./Libraries/STM32_Cryptographic_Library/binary/MK-ARM/: M4_CryptoFW_RngHW_2_0_6.lib
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group at_device
    packages/at_device-latest/: at_socket_esp8266.c
    ./packages/at_device-latest/: at_socket_sim7600.c modul_ctr.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c
  group fal
    ./packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c fal_flash_stm32f4_port.c
  group mbedtls
    ./packages/mbedtls-v2.6.0/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ./packages/mbedtls-v2.6.0/ports/src/: timing_alt.c tls_certificate.c tls_client.c tls_hardware.c tls_net.c
  group ota_downloader
    ./packages/ota_downloader-latest/src/: http_ota.c
  group paho-mqtt
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group WebClinet
    ./packages/webclient-v2.0.1/src/: webclient.c webclient_file.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../components/libc/compilers/common/: gmtime_r.c
  group pthreads
    ../../components/libc/pthreads/: mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
    ../../components/libc/time/: clock_time.c posix_sleep.c
  group AT
    ../../components/net/at/src/: at_utils.c at_client.c
    ../../components/net/at/at_socket/: at_socket.c
  group SAL
    ../../components/net/sal_socket/src/: sal_ipaddr.c sal_socket.c
    ../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal_socket/impl/: af_inet_at.c proto_mbedtls.c
    ../../components/net/sal_socket/dfs_net/: dfs_net.c
  group TQ01_net
    ./TQ01_net/: network.c utils_hmac.c utils_md5.c disguise_time.c mqtt_client.c paho_mqtt_pipe.c
  group usr
    ./usr/modules/: syslog.c authentication.c require_calc.c alarm_calc.c output_ctrl.c req_execution.c event_record.c daq.c sys_status.c team.c password.c reg_map_check.c
  group modbus_slave
    ./FreeModbus/port/: port.c portevent.c portserial.c porttimer.c user_mb_app.c
    ./FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ./FreeModbus/modbus/functions/: mbfuncholding.c mbutils.c mbfuncother.c
    ./FreeModbus/modbus/: mb.c
  group modbus_master
    ./FreeModbus/port/: portevent_m.c portserial_m.c porttimer_m.c user_mb_app_m.c
    ./FreeModbus/modbus/rtu/: mbrtu_m.c
    ./FreeModbus/modbus/functions/: mbfuncholding_m.c
    ./FreeModbus/modbus/: mb_m.c
  group modbus_monitor
    ./FreeModbus/port/modbus_monitor_slave/: mb_event_cpad.c portserial_cpad.c porttimer_cpad.c user_mb_app_cpad.c
  group pcf8563
    ./packages/pcf8563/: pcf8563.c iic_dev.c
  group kits
    ./kits/: calc.c fifo.c Delay.c cyc_buff.c
  group threads
    ./usr/threads/: cpad_thread.c daq_thread.c core_thread.c surv_thread.c team_thread.c testcase_thread.c bkg_thread.c
